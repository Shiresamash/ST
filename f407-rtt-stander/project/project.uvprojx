# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;components\libc\compilers\common;components\libc\compilers\common\extension;libcpu\arm\common;libcpu\arm\cortex-m4;components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;components\finsh;.;include;components\libc\posix\io\poll;components\libc\posix\io\stdio;components\libc\posix\ipc;examples\utest\testcases\kernel;cmsis;driver\config\f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\linker_scripts\link.sct
  group Applications
    ../applications/: main.c
  group Compiler
    ../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../components/libc/compilers/common/: time.c stdlib.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/ipc/: ringblk_buf.c pipe.c ringbuffer.c completion.c waitqueue.c dataqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Finsh
    ../components/finsh/: shell.c msh.c cmd.c
  group cpu_port
    ../../../libcpu/: backtrace.c context_rvds.S cpuport.c div0.c showmem.c
    ../../../cmsis/: startup_stm32f407xx.s system_stm32f4xx.c
  group kernel
    ../../../kernel/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group hal
    ../../../hal/: stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c
    ../hal/: stm32f4xx_hal.c
  group drv
    ../driver/: board.c drv_common.c drv_gpio.c drv_usart.c
